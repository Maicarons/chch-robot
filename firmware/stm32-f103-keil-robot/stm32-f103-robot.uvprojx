# Keil uVision project stm32-f103-robot.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32-f103-robot
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\esp8266;.\Driver\pump_valve;.\Driver\motor;.\Driver\ik
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./esp8266/: esp8266.c
    ./: robot_main.c
    ./Driver/pump_valve/: pump_valve.c
    ./Driver/motor/: motor.c
    ./Driver/ik/: ik.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
